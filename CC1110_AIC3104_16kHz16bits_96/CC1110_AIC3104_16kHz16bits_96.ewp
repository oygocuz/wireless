# IAR project CC1110_AIC3104_16kHz16bits_96.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1110F32.i51
  ICC8051.CCDefines: CC1110; chip=1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: inc
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1111F32.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG; CC1110; chip=1111
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1110F32.xcl
  group (top)
    inc/: board.h hal.h TLV320AIC3104.h
    src/: i2c.c init_Codec.c init_peripherals.c tw_dma.c tw_interrupt.c tw_mac.c tw_main.c tw_rf.c
