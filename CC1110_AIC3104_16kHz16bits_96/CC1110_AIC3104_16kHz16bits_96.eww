<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC1110_AIC3104_16kHz16bits_96.ewp</path>
  </project>
  <batchBuild/>
</workspace>


