# IAR project simple_audio_dongle.ewp, settings and files
configuration rfusb_cc2511 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC1111F32.i51
  ICC8051.CCDefines: MRFI_CC2511; MCU_H="ioCC2511.h"; MRFI; MRFI_MAX_PAYLOAD_SIZE=53; MAX_HOPS=1; chip=2511; BSP_CONFIG_CLOCK_MHZ=24
  ICC8051.CCDiagSuppress: Pe001,Pa082,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/apps/simple_audio; ../../../source/Components/SimpliciTI/mrfi; ../../../source/Components/SimpliciTI/bsp; ../../../source/Components/SimpliciTI/bsp/drivers; ../../../source/Components/SimpliciTI/bsp/boards/rfusb; ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/common/cc8051; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/components/radios/ccxx10; ../../../source/Components/targets/ccxx11_dongle; ../../../source/Components/usb/library; ../../../source/Components/usb/class_audio; ../../../RF_inc
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  A8051.ADefines: chip=1111
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC1111F32.xcl
  group application/common
    ../../../source/apps/simple_audio/: simple_audio_dongle.c
  group hal/common
    ../../../source/Components/common/cc8051/: hal_cc8051.h
    ../../../source/Components/common/: hal_defs.h hal_int.c hal_types.h
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_button.h hal_int.h hal_led.h hal_mcu.h hal_timer_32k.h
  group hal/radio/ccxx10
    ../../../source/Components/radios/ccxx10/: clock.c hal_mcu.c hal_timer_32k.c
    ../../../source/components/radios/ccxx10/: clock.h
  group hal/rfusb
    ../../../source/Components/targets/ccxx11_dongle/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_led.c
  group RF
    ../../../RF_src/: init_peripherals.c tw_dma.c tw_fh.c tw_interrupt.c tw_mac.c tw_rf.c
  group RF_inc
    ../../../RF_inc/: hal_CC2510.h twoway.h
  group usb/class_audio
    ../../../source/components/usb/class_audio/: usb_audio.c usb_audio_controls.c usb_audio_controls.h usb_audio_descriptor.s51 usb_audio_hooks.c usb_class_requests.c usb_class_requests.h usb_firmware_library_config.c
    ../../../source/Components/usb/class_audio/: usb_audio.h usb_firmware_library_config.h usb_firmware_library_headers.h
  group usb/library
    ../../../source/Components/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group usb/library/ccxx11
    ../../../source/Components/usb/library/ccxx11/: usb_interrupt.c usb_suspend.c
  group utilities
    ../../../source/Components/utils/: util.h util_buffer.c util_buffer.h
